# Keil uVision project uCOSDemo.uvproj, settings and files
target uCOSDemo (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: uCOSDemo +hex
  c flags: OneElfS=1
  c include: .\Source\APP;.\Source\BSP;.\Source\FWLib;.\Source\Startup;.\Source\uCOS-II\Source;.\Source\uCOS-II\uC-CPU;.\Source\uCOS-II\uC-LIB;.\Source\uCOS-II\Ports;.\Source\uCGUI\Config;.\Source\uCGUI\emWinDemo;.\Source\uCGUI\inc;.\Source\uCGUI\LCDDriver;.\Source\uCGUI\uCGUIDemo;.\Source\SYSTEM\sys;.\Source\SYSTEM\delay;.\Source\SYSTEM\usart
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ./Source/Startup/: cortexm3_macro.s stm32f10x_startup.s
  group APP
    ./Source/APP/: app.c app_cfg.h includes.h os_cfg.h stm32f10x_it.c stm32f10x_conf.h
  group BSP
    ./Source/BSP/: bsp.c
  group FWLib
    ./Source/FWLib/src/: stm32f10x_bkp.c stm32f10x_dbgmcu.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_rtc.c stm32f10x_flash.c stm32f10x_adc.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_sdio.c stm32f10x_usart.c stm32f10x_wwdg.c
  group uCOS-Ⅱ/Ports
    ./Source/uCOS-II/Ports/: os_cpu_c.c os_dbg.c os_cpu.h os_cpu_a.asm
  group uCOS-II/CPU
    ./Source/uCOS-II/uC-CPU/: cpu_a.asm cpu_def.h cpu.h
  group uCOS-Ⅱ/Source
    ./Source/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uCOS-Ⅱ/GUI_X
    ./Source/uCGUI/: GUI_X_Touch.c GUI_X_uCOS.c
  group uCGUI/LCDDriver
    ./Source/uCGUI/LCDDriver/: ili9320_ucgui.c ili9320_api.c ILI93xx.c
  group uCGUI/Config
    ./Source/uCGUI/Config/: GUIConf.h GUITouchConf.h LCDConf.h
  group uCGUI/Demo
    ./Source/uCGUI/uCGUIDemo/: GUIDEMO.c GUIDEMO_Automotive.c GUIDEMO_Bitmap.c GUIDEMO_Bitmap4bpp.c GUIDEMO_Circle.c GUIDEMO_ColorBar.c GUIDEMO_ColorList.c GUIDEMO_Cursor.c GUIDEMO_Dialog.c GUIDEMO_Font.c GUIDEMO_FrameWin.c GUIDEMO_Graph.c GUIDEMO_HardwareInfo.c GUIDEMO_Intro.c GUIDEMO_LUT.c GUIDEMO_MemDevB.c GUIDEMO_Messagebox.c GUIDEMO_Navi.c GUIDEMO_Polygon.c GUIDEMO_ProgBar.c GUIDEMO_Speed.c GUIDEMO_Touch.c GUIDEMO_WM.c MainTask.c MicriumLogo.c MicriumLogoWRed.c
  group uCGUI/Lib
    ./Source/uCGUI/: uCGUI.lib
  group SYSTEM
    ./Source/SYSTEM/delay/: delay.c
    ./Source/SYSTEM/sys/: sys.c
    ./Source/SYSTEM/usart/: usart.c
